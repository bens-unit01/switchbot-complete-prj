# Keil uVision project Switchbot.uvproj, settings and files
target Switchbot (ARM-ADS)
  device: M0516LAN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Switchbot
  AfterMake: fromelf --bin ".\output\@L.axf" --output ".\output\@L.bin"
  AfterMake: fromelf --text -c ".\output\@L.axf" --output ".\output\@L.txt"
  c flags: Optim=1
  c include: ..\..\Libraries\Include;..\..\Libraries\MiP_Libraries
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source
    ./Source/: switchbotMain.c
  group Common
    ../../Libraries/Common/: common.c retarget.c startup_M051.s
  group MiP Libraries
    ../../Libraries/MiP_Libraries/System_Clock/: System_Clock.c
    ../../Libraries/MiP_Libraries/UART/: UART.c
    ../../Libraries/MiP_Libraries/SPI/: SPI.c
    ../../Libraries/MiP_Libraries/IMU/: IMU.c
    ../../Libraries/MiP_Libraries/Timers/: Timers.c
    ../../Libraries/MiP_Libraries/GPIO/: GPIO.c
    ../../Libraries/MiP_Libraries/PWM/: PWM.c
    ../../Libraries/MiP_Libraries/Encoders/: Encoders.c
    ../../Libraries/MiP_Libraries/Motor_drive/: Motor_Drive.c
    ../../Libraries/MiP_Libraries/Estimator/: Estimator.c
    ../../Libraries/MiP_Libraries/ADC/: ADC.c
    ../../Libraries/MiP_Libraries/Robot_Values/: Robot_Values.h
    ../../Libraries/MiP_Libraries/Interrupt_Priority/: Interrupt_Priority.c
